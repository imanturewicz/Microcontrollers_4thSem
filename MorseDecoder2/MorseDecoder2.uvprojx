# Keil uVision project MorseDecoder2.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: LPC4088FET208 NXP
  pack: Keil.LPC4000_DFP.2.2.2
  cpu: IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MorseDecoder2
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\drivers
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./drivers/: i2c.c timer.c gpio.c dac.c comparator.c adc.c uart.h timer.h platform.h i2s.h i2c.h gpio.h dma.h dac.h comparator.h adc.h uart.c
    ../4-GPIOLabBasicUI/src/: delay.c delay.h lcd.c lcd.h leds.c leds.h switches.c switches.h
  group New Group
    ./: adc_conversion.h adc_conversion.c main.c
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.16.2, Device:Startup 1.0.1
